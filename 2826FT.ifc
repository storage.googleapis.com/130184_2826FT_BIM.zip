Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-06-20T11:02:41
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.2.0.0 - Alternate UI 16.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 20 11:02:41 2018 * Host: pcz-computer * Database: C:\Users\Paloma\AppData\Local\Temp\{4E947408-C312-4928-A2E7-2FEC07C0C745}\ifc * Database version: 5507 * Database creation date: Wed Jun 20 11:02:40 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 20 11:02:40 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 20 11:02:40 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Identity Data - Type Name: Circle Head - Project Datum; Building Story: yes; Name: Level 0; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcFlowController: 2826FT Washbasin faucet, 230/12 V, 2826FT:2826FT Washbasin faucet, 230/12 V:340552
In: Level 0
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - FaucetNominalDepth: 163.5 mm; FaucetNominalHeight: 147 mm; FaucetNominalWidth: 68.472 mm; HandShowerNominalDepth: 64.5 mm; HandShowerNominalHeight: 286.5 mm; HandShowerNominalWidth: 46 mm; InletConnectionSize: 10 mm
Type - Electrical - Electrical Connection: 230 / 12 V; Electronic Parts: Autofocus sensor; Operating Voltage: 230 V
Type - General - Author: Convergo AB; BIMObjectName: 2826FT; ConvergoRefNr: 0087-1806-0095-FI; ExpiringDate: 12/2018; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for washbasins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 15/06/2018
Type - Green Building Properties - EAN Number: 6414150076480; EMC Directive: 2004/108/EY; LVI Number: 6110189; Noise Class: I (ISO 3822); Protection Class: IP 55 / transformer IP 40; RSK Number: 8430496; STF Certificate: VTT-RTH-00002-10
Type - Identity Data - Class: Touchless, plug transformer; Group: Washbasin faucets; Manufacturer: Oras; Market: INT;DNK;EST;FIN;LVA;LTU;POL;RUS;SWE;UKR; Model: 2826FT Washbasin faucet, 230/12 V; Name_en: 2826FT Washbasin faucet, 230/12 V; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 2826FT; Product Datasheet: https://www.oras.com/datasheet/2826FT/en; Product Family: Oras Cubista; Product URL: https://www.oras.com/en/products/oras-cubista/product/2826FT/; Type Name: 2826FT Washbasin faucet, 230/12 V; Usage Group: Offices, pharmacies, health centers
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Flow: Limitation option for maximum flowrate; Flow Rate At 300kPa With Flow Controller: 0.00353147 m3/s; Hand Shower: Bidetta handshower; Installation Type: Deck mounted; Intelligent After Flow Period: 2 s ± 1 s; Lever Handle: Temperature control handle; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 120; Mechanical Parts: Litter filter; Pipes: Flexible inlet pipes; Pressure Loss With Flow 01ls: 250000 Pa; Recognition Range: optimally preset
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 2826FT; Features: Touchless, plug transformer; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 2826FT; Name: 2826FT Washbasin faucet, 230/12 V; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet:64x164x163 mm / Hand shower: 46x65x286 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 2826FT; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 2826FT Washbasin faucet, 230/12 V
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Host: Level : Level 0; Level: Level: Level 0; Offset: 0 mm
Dimensions - Area: 0.0810198 m2; Volume: 0.00250045 m3
Identity Data - Mark: 20
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 2826FT: 2826FT Washbasin faucet, 230/12 V; Family and Type: 2826FT: 2826FT Washbasin faucet, 230/12 V; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 2826FT: 2826FT Washbasin faucet, 230/12 V; Type Id: 2826FT: 2826FT Washbasin faucet, 230/12 V; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
